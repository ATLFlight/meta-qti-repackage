inherit import-package

HOMEPAGE = "https://developer.qualcomm.com"

PREBUILT_DIR = "${COREBASE}/../prebuilt_${MACHINE}/${PREBUILT_VERSION}/"

IMPORT_LICENSE_PKGNAME = "qti-license-redistributable"

PV = "1.0"
PR = "r0"


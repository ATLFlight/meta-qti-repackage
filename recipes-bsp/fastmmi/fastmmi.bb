inherit qti-pkg

DESCRIPTION = "fastmmi"
HOMEPAGE = "http://support.cdmatech.com"

RDEPENDS_${PN} += "frameworks-av libxml2 zlib glib-2.0 diag camera-hal sdk-add-on"

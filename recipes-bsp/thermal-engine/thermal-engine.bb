inherit qti-pkg

DESCRIPTION = "Thermal Engine"
SECTION = "base"

INITSCRIPT_NAME = "thermal-engine"
INITSCRIPT_PARAMS = "start 40 2 3 4 5 . stop 60 0 1 6 ."

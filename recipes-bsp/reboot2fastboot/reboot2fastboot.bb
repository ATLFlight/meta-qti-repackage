inherit qti-pkg

DESCRIPTION = "reboot2fastboot causes target system to reboot into fastboot mode."


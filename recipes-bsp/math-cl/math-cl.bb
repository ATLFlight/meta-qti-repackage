inherit qti-pkg

DESCRIPTION = "math-cl tests OpenCL fast-math"

RDEPENDS_${PN} += "adreno200 "


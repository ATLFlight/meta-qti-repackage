inherit qti-pkg

DESCRIPTION = "Video encoder applications"
SECTION = "base"

RDEPENDS_${PN} = "mm-mux-noship"

inherit qti-pkg


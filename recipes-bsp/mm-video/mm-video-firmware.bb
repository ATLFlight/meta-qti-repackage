inherit allarch qti-pkg

INSANE_SKIP_${PN} = "arch"

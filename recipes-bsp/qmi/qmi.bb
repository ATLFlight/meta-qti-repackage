inherit qti-pkg

DESCRIPTION = "Qualcomm MSM Interface (QMI) Library"
HOMEPAGE = "http://support.cdmatech.com"

RDEPENDS_${PN} = "dsutils glib-2.0 diag xmllib configdb"

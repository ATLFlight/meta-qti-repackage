inherit qti-pkg

DESCRIPTION = "ATH6KL (QCA6234) WLAN Firmware"

inherit qti-pkg

DESCRIPTION = "ath6kl utilities"
HOMEPAGE = "http://support.cdmatech.com"

RDEPENDS_${PN} = "libnl-route libnl glib-2.0 libnl-nf libnl-genl"

inherit qti-pkg

DESCRIPTION = "ftmdaemon"
HOMEPAGE = "http://support.cdmatech.com"


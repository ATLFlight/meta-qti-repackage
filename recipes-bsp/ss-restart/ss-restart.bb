inherit qti-pkg

DESCRIPTION = "Subsystem Restart utilities"
HOMEPAGE = "http://support.cdmatech.com"

RDEPEND_${PN} = "glib-2.0"

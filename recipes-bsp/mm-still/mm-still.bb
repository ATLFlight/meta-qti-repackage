inherit qti-pkg

DESCRIPTION = "MM Image processing library for MSM/QSD"
SECTION = "base"

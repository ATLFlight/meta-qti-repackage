inherit qti-pkg

DESCRIPTION = "QMI Framework Library"

RDEPENDS_${PN} +="qmi "

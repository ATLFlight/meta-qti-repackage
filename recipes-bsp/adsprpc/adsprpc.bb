inherit qti-pkg

RPROVIDES_${PN} += "libadsprpc.so libadsprpc.so(ADSPRPC) libmdsprpc.so libmdsprpc.so(MDSPRPC)"


inherit qti-pkg

DESCRIPTION = "mm-camera-core prebuilt libraries"
SECTION = "base"


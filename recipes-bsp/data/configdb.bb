inherit qti-pkg

DESCRIPTION = "Qualcomm Data Configdb Module"
HOMEPAGE = "http://support.cdmatech.com"

RDEPENDS_${PN} = "diag xmllib dsutils glib-2.0"

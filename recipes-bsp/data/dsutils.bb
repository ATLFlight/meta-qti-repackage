inherit pkgconfig qti-pkg

DESCRIPTION = "Qualcomm Data DSutils Module"
HOMEPAGE = "http://support.cdmatech.com"

RDEPENDS_${PN} = "glib-2.0 diag"

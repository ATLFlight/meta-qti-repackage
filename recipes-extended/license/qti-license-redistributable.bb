inherit allarch
inherit qti-pkg
